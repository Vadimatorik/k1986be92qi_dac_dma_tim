# Keil uVision project Game.uvprojx, settings and files
target Game (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Game
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\flash;.\Libraries\1986BE9x_StdPeriph_Driver\inc;.\mlt;.\User;.\Lib_Config;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\1986BE9x\startup\arm;.\Libraries\CMSIS\CM3\DeviceSupport\1986BE9x\inc;C:\Game_in_1986BE92QI;.\Libraries\1986BE9x_StdPeriph_Driver\src;.\Libraries\1986BE9x_StdPeriph_Driver;.\Libraries\CMSIS\CM3\DeviceSupport\1986BE9x\inc;.\User\C;.\User\H
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/C/: main.c 1986BE92QI_CLK.c 1986BE92QI_DMA.c 1986BE92QI_PORT.c 1986BE92QI_TIM.c 1986BE92QI_DAC.c
    ./User/: history.c
  group LCD
    ./mlt/: mlt_lcd.c
  group Flash
    ./flash/: MilFlash.c
  group SMSIS_and_Drivers
    ./Libraries/CMSIS/CM3/DeviceSupport/1986BE9x/startup/arm/: startup_1986be9x.s system_1986BE9x.c
    ./Libraries/1986BE9x_StdPeriph_Driver/src/: 1986be9x_dma.c 1986be9x_eeprom.c 1986be9x_port.c 1986be9x_rst_clk.c 1986be9x_uart.c
